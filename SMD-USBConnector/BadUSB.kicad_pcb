# Repository joelsernamoreno/Attiny85-Standalone

File README.md:

# Attiny85-Standalone
PCB designs based on the Attiny85 microcontroller for standalone development.

These devices have been designed for the final development of BadUSB-Cable:

https://github.com/joelsernamoreno/BadUSB-Cable

**Idea:** Joel Serna & Ernesto Sánchez

**Development and implementation:** Joel Serna & Ernesto Sánchez

**PCB design:** Ignacio Díaz Álvarez

# Acknowledgement

**PCBs design:** Ignacio Díaz & ForensicSecurity

	* Ignacio Díaz: @Ignacio Díaz Álvarez

	* Forensic & Security: @ForensicSec

	* https://forensic-security.com

# Electronic components

**SMD-USB Connector:**

**THT Version:**

## Import the project
There is a custom built library footprints for this project, remember to import it.

## Introduction
You can order the necessary components with the gerber files in the gerber directory and de BOM (Bill Of Materials).

## Hardware needed

To burn the bootloader you can use diferent techniques, for the one we use you will need:

* TEST CLIP SOIC 8 (2 X 4)  
* TINY AVR PROGRAMMER 

## Download bootloader

* Download Micronucleus bootloader for ATTINY85: https://github.com/micronucleus

* You can find the bootloader file at micronucleus-t85\firmware\releases folder

* Use "t85_default.hex" for the bootloader

## Burning bootloader for ATTINY85

You must use the correct fuses bit for the bootloader:

* **Extended:** 0xFE
* **High:** 0xDD
* **Low:** 0xE1

AVRISP MKll In System Programmer and AVR Studio software for burning bootloader

## Installing Digispark USB Driver

1. Download Arduino for Digispark which come with USB driver: http://sourceforge.net/projects/digistump/files/

2. Extract the file (DigisparkArduino-Win32-1.0.4-March29.zip) to any folder

3. Execute DigisparkArduino-Win32\DigisparkWindowsDriver\InstallDriver.exe to start installing the USB driver

## Payloads

You can get payloads in the following repository:

https://github.com/joelsernamoreno/badusb_examples/tree/master/attiny85_digispark

## KiCad design SMD-USBConnector/BadUSB.kicad_pcb

Board: 2 copper layers, 12.1 x 18.5 mm, 6 parts (4 on the bottom side), 6 nets.

Parts:
D1: D_Zener_x2_ACom_KKA; TSOT-23
J1: USB_A; usb-PCB
R1, R2: 68R; R_0402_1005Metric
R3: 1K5; R_0402_1005Metric
U1: ATtiny85V-10SU; SOIJ-8_5.3x5.3mm_P1.27mm

Connections:
+D: D1.1, J1.3, R1.2
+V: J1.1, R3.1, U1.8
-D: D1.2, J1.2, R2.2, R3.2
GND: D1.3, J1.4, U1.4
unnamed: R1.1, U1.3
unnamed: R2.1, U1.2

## Commit log

2019-08-13 first test
2019-08-13 second test
2019-08-13 add licence
